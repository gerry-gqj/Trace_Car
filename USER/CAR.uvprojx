# Keil uVision project CAR.uvprojx, settings and files
target CAR_DRIVER (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CAR +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\CAR_STATUS;..\HARDWARE\MOTOR_PWM;..\HARDWARE\MOTOR_STATUS;..\HARDWARE\TRACE_CTRL;..\HARDWARE\INFRARED_STATUS
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_tim.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/MOTOR_PWM/: motor_pwm.c
    ../HARDWARE/MOTOR_STATUS/: motor_status.c
    ../HARDWARE/CAR_STATUS/: car_status.c
    ../HARDWARE/INFRARED_STATUS/: infrared_status.c
    ../HARDWARE/TRACE_CTRL/: trace_ctrl.c
